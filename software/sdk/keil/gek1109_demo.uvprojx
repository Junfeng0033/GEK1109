# Keil uVision project gek1109_demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: gek1109_demo +hex
  AfterMake: build.bat
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\include;.\user;.\lcd
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1000
  scatter file: .\scatter_gek1109_demo.sct
  group startup
    ./startup/: startup_cm0.s system_initial.c
  group peripheral
    ./peripheral/: adc.c aon.c cmu.c iomux.c isr.c uart.c gpio.c gpio_i2c.c spi.c timer.c systick.c pwm.c watchdog.c dma2d.c efuse.c
  group norflash
    ./norflash/xtxflash/: dpi_common.c xt25f32.c
  group gui
    ./gui/: circle_100x100.c font_0_9_digital_32b.c font_A_z_32b.c
  group lcd
    ./lcd/: lcd_driver.c
  group user
    ./user/: 120x240_32bit.c 120x240_1_32bit.c main.c key_process.c
